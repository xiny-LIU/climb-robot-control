# Keil uVision project main.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware/bluetooth;../Hardware/buzzer;../Hardware/can;../Hardware/imu;../Hardware/Led;../Hardware/num_command;../Hardware/PS2;../Hardware/pwm_motor;../Hardware/user_tim;../Hardware/user_usart;../Hardware
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group hardware_user
    ../Hardware/bluetooth/: bluetooth_motor.c
    ../Hardware/buzzer/: buzzer.c
    ../Hardware/Led/: led.c
    ../Hardware/num_command/: num_command.c
    ../Hardware/pwm_motor/: pwm_motor.c
    ../Hardware/user_tim/: user_tim.c
    ../Hardware/user_usart/: user_usart.c
  group AX_user
    ../Hardware/PS2/: ps2.c ps2_control.c ps2_filter.c
  group imu_user
    ../Hardware/imu/: analysis_data.c usart6.c
  group M3508_user
    ../Hardware/can/: bsp_can.c CAN_receive.c encoder_counter.c PID.c
software components: CMSIS:CORE 4.3.0
